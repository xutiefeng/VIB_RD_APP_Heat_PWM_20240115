# Keil uVision project VIB_APP.uvprojx, settings and files
target Sources (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: S32K116xxxxMFMx NXP
  pack: Keil.S32K116_SDK_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00002000) IRAM2(0x20002000,0x00001800) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: VIB_APP +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c include: .\Sources;.\Sources\App;.\Sources\User;.\Sources\Device;.\Sources\Hardware;.\SDK\platform\devices;.\SDK\platform\devices\S32K116\include;.\SDK\platform\devices\S32K116\startup;.\SDK\platform\drivers\inc;.\SDK\platform\drivers\src\adc;.\SDK\platform\drivers\src\clock;.\SDK\platform\drivers\src\clock\S32K1xx;.\SDK\platform\drivers\src\edma;.\SDK\platform\drivers\src\flexcan;.\SDK\platform\drivers\src\interrupt;.\SDK\platform\drivers\src\pins;.\SDK\platform\drivers\src\wdog;.\SDK\rtos\osif;.\Sources\projectsel;.\Generated_Code;.\Sources\DiagLib
  memory RVCT4: ROM 0xa000 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x1800
  scatter file: .\Sources\S32K116_17_flash_APP.scf
  group Main
    ./Sources/: includeall.h Main.h Main.c
    ./Sources/RDBsp/: config.h
    ./Sources/App/: Rte.h Rte.c
  group Hardware
    ./Sources/Hardware/: CAN.c CAN.h FLEXCAN.c FLEXCAN.h flexcan_driver.h flexcan_hw_access.c flexcan_hw_access.h LPUART.c LPUART.h lpuart_driver.h lpuart_hw_access.c lpuart_hw_access.h SYS.c SYS.h ADC.c ADC.h EEPROM.c EEPROM.h
  group User
    ./Sources/User/: Crc.c Crc.h Flag.c Flag.h Stat.c Stat.h Time.c Time.h
  group RDBsp
    ./Sources/RDBsp/: bsp_ADCollect.c bsp_eeprom.c bsp_Led.c bsp_uart.c buzzer.c clib.c FuncTab.c globe.c key.c CDCMessage.c TELMessage.c UpdataCanMessage.c Display.c factory.c sysRun.c
  group Generated
    ./Generated_Code/: adConv1.c adConv1.h clockMan1.c clockMan1.h Cpu.c Cpu.h dmaController1.c dmaController1.h flexTimer_mc1.c flexTimer_mc1.h flexTimer_pwm1.c lpspiCom1.c lpspiCom1.h lpTmr1.c lpTmr1.h pin_mux.c pin_mux.h pwrMan1.c pwrMan1.h watchdog1.c watchdog1.h
  group platform_decices
    ./SDK/platform/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group platform_decices_S32K116
    ./SDK/platform/devices/S32K116/include/: S32K116.h S32K116_features.h
    ./SDK/platform/devices/S32K116/startup/: system_S32K116.c system_S32K116.h
  group platform_drivers_inc
    ./SDK/platform/drivers/inc/: adc_driver.h clock.h clock_manager.h interrupt_manager.h pins_driver.h wdog_driver.h edma_driver.h lpspi_master_driver.h lpspi_shared_function.h lpspi_slave_driver.h lptmr_driver.h power_manager.h ftm_common.h ftm_mc_driver.h
  group platform_drivers_src
    ./SDK/platform/drivers/src/adc/: adc_driver.c adc_hw_access.h
    ./SDK/platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h pcc_hw_access.h pmc_hw_access.h scg_hw_access.h sim_hw_access.h smc_hw_access.h
    ./SDK/platform/drivers/src/interrupt/: interrupt_manager.c
    ./SDK/platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ./SDK/platform/drivers/src/wdog/: wdog_driver.c wdog_hw_access.c wdog_hw_access.h
    ./SDK/platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c lptmr_hw_access.h
    ./SDK/platform/drivers/src/lpspi/: lpspi_hw_access.c lpspi_hw_access.h lpspi_irq.c lpspi_master_driver.c lpspi_shared_function.c lpspi_slave_driver.c
    ./SDK/platform/drivers/src/edma/: edma_driver.c edma_hw_access.c edma_hw_access.h edma_irq.c edma_irq.h
    ./SDK/platform/drivers/src/power/S32K1xx/: power_manager_S32K1xx.c power_manager_S32K1xx.h power_rcm_hw_access.h power_scg_hw_access.h power_smc_hw_access.c power_smc_hw_access.h
    ./SDK/platform/drivers/src/power/: power_manager.c
    ./SDK/platform/drivers/src/ftm/: ftm_common.c ftm_hw_access.c ftm_hw_access.h ftm_mc_driver.c ftm_pwm_driver.c
  group rtos
    ./SDK/rtos/osif/: osif.h osif_baremetal.c
  group Keil
    ./Sources/: startup_S32K116.S
  group VIBDiag
    ./Sources/App/: AES.h CanAll.h CanApp.h CanDiag.h CanNM2.h CanTp.h CarSign.h DiagDid.h DiagSid.h DiagSub.h DiagTask.h Dtc.h ECU_Variant.h EepAll.h EepApp.h Info.h SeedKey.h
    ./Sources/DiagLib/: VIB_Diag.lib
